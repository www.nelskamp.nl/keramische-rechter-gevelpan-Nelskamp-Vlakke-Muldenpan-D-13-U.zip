Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 56990ab2-e1ee-410c-aa0f-fb59004d7476.ifc
Time: 2022-04-14T14:56:37
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcBuildingElementProxy
In: Bouwlaag
Material: terracotta
Pset_Data - WUID: AgAAAJ_9xwABAAAAmaMAAAVWkAAAzUgAAFrgAADupAAAcVsAAAAA; Hyperlink: https://bcb-online.nl/s/03062eb7e1f034ad0803f4ea934314dc2; serie: Vlakke Muldenpan D-13-U; soortelijke warmte: 840 j/kg·k; KOMO productcertificaat: True; NL-SfB tabel 3: g9; vorstbestendig: True; merk: Nelskamp; KOMO attest: True; STABU2: 33.41.10; lengte: 439 mm; eenheid: st
